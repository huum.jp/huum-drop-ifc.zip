Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: Drop.blend.ifc
Time: 2023-04-05T15:00:32+03:00
Written by: IfcOpenShell v0.7.0-476ab506d
Made in: BlenderBIM 0.0.230304
Authorization: Nobody

# IfcActuator (149)
PredefinedType: ELECTRICACTUATOR
Name
22 x 1
22 x 2
24 x 4
21 x 6
20 x 7
20 x 3
19 x 5
DROP
